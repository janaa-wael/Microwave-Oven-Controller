# Keil uVision project Microwave.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Microwave
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s system_TM4C123.c
  group LIB
    ./LIB/: BIT_MATH.h STD_TYPES.h tm4c123gh6pm.h
  group MCAL
    ./MCAL/GPIO/: GPIO.c GPIO.h
    ./MCAL/SYSTICK/: SYSTICK.c SYSTICK.h
  group HAL
    ./HAL/KEYPAD/: KEYPAD.c KEYPAD.h
    ./HAL/LCD/: LCD.c LCD.h
    ./HAL/PUSH_BTN/: PUSH_BTN.c PUSH_BTN.h
    ./: SWITCH.c
  group APP
    ./APP/: main.c
